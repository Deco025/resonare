# Repository Deco025/resonare

File README.md:

# Resonare

**120 W LCC-S 谐振式无线充电：发射板 + 接收板**

> *Resonare* (Latin: “to resound”) is an open-source 120 W wireless charger built on an LCC-S resonant
> topology. A 24 V transmitter drives a full bridge into an LCC compensation network; the receiver rectifies,
> steps down with a synchronous buck and charges a supercapacitor bank through an ideal-diode stage.
> Both boards are 4-layer KiCad 10 designs with complete fabrication outputs.

| 发射板 TX（82 × 60 mm） | 接收板 RX（75 × 60 mm） |
|---|---|
|  |  |

### PCB 走线

| | 顶层 F.Cu | 底层 B.Cu（从背面看） |
|---|---|---|
| **发射板 TX** |  |  |
| **接收板 RX** |  |  |

第 2 层为整层地、第 3 层为整层电源（TX：VBUS；RX：VRECT），图中只画出两个外层。

---

## 目录

- [主要指标](#主要指标)
- [系统结构](#系统结构)
- [仓库结构](#仓库结构)
- [打开工程](#打开工程)
- [打样与装配](#打样与装配)
- [设计要点](#设计要点)
- [安全提示](#安全提示)
- [许可证](#许可证)
- [致谢](#致谢)

## 主要指标

| 项 | 值 |
|---|---|
| 发射端输入 | 24 V DC，XT30 接口，输入平均电流约 5.9 A（按 85 % 效率估算） |
| 输出功率 | 120 W 级（超级电容端） |
| 拓扑 | 全桥逆变 + LCC-S 补偿 |
| 逆变 / 谐振频率 | 144 kHz |
| 补偿参数 | Lf 6 µH；Lt = Lr 20 µH；Cf ≈ 203.6 nF，Ct ≈ 87.3 nF，Cr ≈ 61.1 nF（理想调谐） |
| 整流母线 VRECT | 标称 30 V |
| 接收端降压 | 同步 Buck，200 kHz，15 µH；充电电流上限 10 A（峰值约 11.2 A） |
| 负载 | 超级电容组，6–24 V，等效 10 F，XT60 接口 |
| 电流采样 | 2 mΩ 四端分流电阻 + INA240A2（×50）：10 A → 1.0 V |
| 主控 | TX：STM32G474CE（HRTIM 驱动全桥）；RX：STC32G12K128（PWM 驱动 Buck） |
| PCB | 4 层，1.6 mm，外层 2 oz / 内层 1 oz |

## 系统结构

```mermaid
flowchart LR
    subgraph TX [发射板]
        IN[24 V 输入<br/>保险丝 · TVS · 电流采样] --> FB[全桥<br/>4 × BSC070N10NS3G<br/>2 × UCC27211]
        FB --> LCC[LCC 补偿<br/>Lf · Cf · Ct]
        MCUT[STM32G474<br/>HRTIM · ADC · 比较器] --> FB
        AUXT[辅助电源<br/>24→12 V / 5 V / 3.3 V]
    end
    LCC -. 线圈 Lt ~ 磁耦合 ~ Lr .-> RECT
    subgraph RX [接收板]
        RECT[Cr + 全桥整流<br/>4 × SB2060L] --> BUCK[同步 Buck<br/>2 × BSC070N10NS3G<br/>UCC27211]
        BUCK --> OUT[电流采样 · 理想二极管<br/>LM74700 + N-MOS]
        OUT --> CAP[(超级电容组)]
        MCUR[STC32G12K128<br/>PWM · ADC · 比较器] --> BUCK
        AUXR[辅助电源<br/>VRECT→12 V / 5 V / 3.3 V]
    end
```

- 发射端过流保护：INA240 输出同时进 ADC 和片内比较器（COMP1），比较器直接触发 HRTIM 故障关断。
- 接收端过流保护：充电电流进 ADC 和片内比较器，比较器阈值用片内 1.19 V 基准，对应约 11.9 A。
- 防倒灌：同步 Buck 上管的体二极管会让超级电容反向放电到 VRECT，所以输出端串联 LM74700 + N-MOS 理想二极管，由 MCU 的 `CHG_EN` 控制。
- 接收端的辅助电源只从 VRECT 取电。小车离开发射线圈后，接收端 MCU 掉电，Buck 停止，理想二极管关断。
- 发射与接收的地完全隔离（`GND` / `GND_RX`）。

更完整的说明见 [docs/design.md](docs/design.md)。

## 仓库结构

```
.
├── p1_tx/                 发射板 KiCad 工程（原理图 + PCB）
│   └── fab/               发射板生产文件（Gerber zip、BOM、坐标、装配图、DRC 报告）
├── p1_rx/                 接收板 KiCad 工程
│   └── fab/               接收板生产文件
├── p1/                    整机原理图（发射与接收在同一个工程里，作系统参考）
│   └── 3dmodels/          第三方 3D 模型的来源清单（模型文件不随仓库分发）
├── docs/
│   ├── design.md          设计说明
│   └── schematics/        原理图 PDF（不装 KiCad 也能看）
├── images/                3D 渲染图
├── CHANGELOG.md
└── LICENSE                CERN-OHL-S-2.0
```

## 打开工程

1. 安装 [KiCad](https://www.kicad.org/) **10.0** 或更新版本。
2. 打开 `p1_tx/p1_tx.kicad_pro`（发射板）或 `p1_rx/p1_rx.kicad_pro`（接收板）。自定义符号在各工程自带的 `p1_parts.kicad_sym` 里；封装全部来自 KiCad 官方库。
3. **3D 模型（可选）**：有 9 种器件的 3D 模型不在 KiCad 官方库里，版权也不允许随仓库再分发。按 [p1/3dmodels/README.md](p1/3dmodels/README.md) 下载到 `p1/3dmodels/`，3D 查看器（`Alt+3`）里就能看到完整模型。不下载也不影响原理图、PCB 和生产文件。

## 打样与装配

生产文件已经导出好，坐标原点在板的左上角：

| | 发射板 | 接收板 |
|---|---|---|
| 上传给板厂 | [`p1_tx/fab/p1_tx-gerber.zip`](p1_tx/fab/p1_tx-gerber.zip) | [`p1_rx/fab/p1_rx-gerber.zip`](p1_rx/fab/p1_rx-gerber.zip) |
| 物料清单 | [`p1_tx-bom.csv`](p1_tx/fab/p1_tx-bom.csv) | [`p1_rx-bom.csv`](p1_rx/fab/p1_rx-bom.csv) |
| 贴片坐标 | [`p1_tx-pos.csv`](p1_tx/fab/p1_tx-pos.csv) | [`p1_rx-pos.csv`](p1_rx/fab/p1_rx-pos.csv) |
| 装配图 | [`p1_tx-assembly.pdf`](p1_tx/fab/p1_tx-assembly.pdf) | [`p1_rx-assembly.pdf`](p1_rx/fab/p1_rx-assembly.pdf) |
| 下单参数 | [`p1_tx/fab/README.md`](p1_tx/fab/README.md) | [`p1_rx/fab/README.md`](p1_rx/fab/README.md) |

下单要点：

- 4 层，1.6 mm FR4，外层 2 oz、内层 1 oz，无铅喷锡，过孔盖油。
- 叠层顺序：F.Cu / In1（地）/ In2（电源：TX 为 VBUS，RX 为 VRECT）/ B.Cu。**内层顺序不能调换**。
- 最小线宽 / 线距 0.2 / 0.2 mm，最小过孔 0.5 / 0.3 mm（焊环 0.1 mm）。外层 2 oz 下请对照板厂工艺能力确认。
- 接收板有 2 个 0.6 × 1.7 mm 金属化槽孔。
- 线圈（L302、L601）在板外，BOM 里的线圈条目不贴装。安装孔 H1–H4 为 M3。
- 为了版面整洁，丝印上放不下的一些小阻容位号只保留在装配层（F.Fab），焊接时请对照装配图。

DRC 里保留了几条已接受的丝印告警：驱动器封装的 1 脚标记压在自举电容焊盘上 0.05–0.14 mm；接线端子外框到达板边。这两种情况板厂都会自动裁掉焊盘上和板外的丝印。

## 设计要点

- **栅极回路最小化**：半桥驱动器夹在上下管的栅极之间，LO / VSS 对着下管，HO 从自举电容两焊盘之间穿出，栅极电阻紧贴 MOS。
- **完整的回流平面**：第 2 层整层是地，第 3 层整层是电源。高 di/dt 的信号都走在顶层，紧贴地平面；底层贴着电源平面，只走慢信号和跨越线。
- **开尔文采样**：四端分流电阻的检测端单独引线，成对走到 INA240；ADC 的 RC 滤波放在 MCU 引脚旁。
- **功率铺铜**：开关节点铺铜面积受控，输入去耦电容紧贴 MOS 管；两面地铺铜，用缝合过孔连到地平面。
- **LCC 电感下方挖空内层**：发射端 Lf 流过全部逆变电流，其下方的内层平面挖空，避免涡流发热。接收端 Buck 电感只有纹波电流，下方平面保留，起屏蔽作用。

详见 [docs/design.md](docs/design.md)。

## 安全提示

- 谐振网络（Cf、Ct、Cr、线圈）上的电压可以远高于直流母线电压，通电时不要触碰。
- 超级电容组储能大、短路电流大：接线前先确认极性（XT60：焊盘 1 为负、焊盘 2 为正），调试时加限流。
- 首次上电请用限流电源，按“辅助电源 → MCU → 驱动 → 小功率 → 满功率”逐级进行。
- 线圈之间留足间隙，使用尼龙柱安装（接收板背面丝印有提示）。

## 许可证

本项目的硬件设计文件（原理图、PCB、生产文件、文档）采用
**[CERN Open Hardware Licence Version 2 – Strongly Reciprocal (CERN-OHL-S-2.0)](LICENSE)**。

简单说：可以自由使用、学习、修改、生产和销售；但如果你发布修改后的设计，或者销售基于它的产品，必须用同样的许可证公开对应的设计源文件。

第三方封装、符号和 3D 模型各自遵循其原始许可，不在本许可证范围内。

## 致谢

- [KiCad](https://www.kicad.org/) 及其官方符号 / 封装 / 3D 库。
- 器件 3D 模型的来源见 [p1/3dmodels/SOURCES.md](p1/3dmodels/SOURCES.md)。

欢迎通过 Issue 反馈问题或提出改进。

## KiCad design p1_tx/p1_tx.kicad_pcb

Parts:
C1: 220uF; CP_Elec_10x10.5; Voltage 50V
C2, C3: 4.7uF; C_1210_3225Metric; Voltage 50V
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
Q1, Q2, Q3, Q4: BSC070N10NS3G; Infineon_PG-TDSON-8_6.15x5.15mm
R1, R2, R3, R4: 10R; R_0603_1608Metric
R6, R7, R8, R9: 10k; R_0603_1608Metric

Connections:
/DRV_AH: R1.1; also elsewhere on the board
/DRV_AL: R2.1; also elsewhere on the board
/DRV_BH: R3.2; also elsewhere on the board
/DRV_BL: R4.2; also elsewhere on the board
/SWA: Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D), R6.2; also elsewhere on the board
/SWB: Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.5 (D), R8.2; also elsewhere on the board
unnamed: Q1.4 (G), R1.2, R6.1
unnamed: Q2.4 (G), R2.2, R7.1
unnamed: Q3.4 (G), R3.1, R8.1
unnamed: Q4.4 (G), R4.1, R9.1

Notes on the sheet:
DRV_* are driver outputs. High-side VGS is referenced to SWA/SWB.
LCC-S 120 W wireless charger - root sheet: TX full bridge + sheet index
Q1-Q4 BSC070N10NS3G (BSC070N10NS3GATMA1): 100 V / 7 mOhm OptiMOS 3. VDS rating is about 4x the 24 V bus, about 2x the 45 V TVS clamp.
RX side (receiver board, isolated ground = GND_RX)
M3 安装孔 ×4（NPTH，板角各一个，PCB 上定位）
Design values: VBUS 24 V, f = 144 kHz, 120 W class. 10R / 10k gate values are starting points.
TX side (transmitter board, ground = GND)
C1 220 uF/50 V bulk; C2/C3 4.7 uF/50 V X7R at each leg carry the 2 x fsw bridge ripple, about 2.4 A rms at 120 W. 50 V covers the 24 V bus and the 45 V TVS clamp.
Full-bridge inverter
SWA/SWB -> sheet TX_LCC. DRV_* <- sheet TX_Driver (UCC27211 x2). PWM with dead time from STM32G474 HRTIM.

Parts:
C101: 10uF; C_1210_3225Metric; Voltage 50V
C102, C105: 100nF; C_0603_1608Metric
C104: 1nF; C_0603_1608Metric
D101: SMAJ28A; D_SMA
F101: 10A; Fuse_Littelfuse-NANO2-451_453
J101: XT30_24V_IN; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
R101: 2m; R_Shunt_Vishay_WSK2512_6332Metric_T1.19mm
R102: 100; R_0603_1608Metric
R103: 150k; R_0603_1608Metric
R104: 10k; R_0603_1608Metric
U101: INA240A2D; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3V3: C102.1, U101.6 (V+); also elsewhere on the board
/TX_Input/ISNS_TX_N: R101.3, U101.1 (-)
/TX_Input/ISNS_TX_P: R101.2, U101.8 (+)
/TX_Input/VIN_FUSED: C101.1, D101.1 (A1), F101.2, R101.1
ISNS_TX: C104.1, R102.2; also elsewhere on the board
unnamed: F101.1, J101.2
unnamed: R102.1, U101.5
VBUS_SNS: C105.1, R103.2, R104.1; also elsewhere on the board

Notes on the sheet:
TX DC input, 24 V. F101 10 A slow-blow: 5.9 A max input at 120 W, rides through the C1 inrush. D101 SMAJ28A: VRWM 28 V > 24 V + 15 %, clamp about 45 V < 60 V (LMR16006). Reverse polarity is prevented by the keyed XT30.
R101 2 mOhm Kelvin shunt + U101 INA240A2 (x50): 6 A -> 0.6 V, full scale about 33 A at 3.3 V.
VBUS_SNS = VBUS x 10k / 160k (24 V -> 1.5 V).
ISNS_TX goes to MCU PA1 (ADC + COMP1 fast over-current into HRTIM fault).

Parts:
C301, C302: 100nF; C_1812_4532Metric; Voltage 250V C0G
C303: 3.3nF; C_1812_4532Metric; Voltage 250V C0G
C304: 82nF; C_1812_4532Metric; Voltage 250V C0G
C305: 5.6nF; C_1812_4532Metric; Voltage 250V C0G
J301: TX_COIL; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
L301: 6uH; L_12x12mm_H8mm
L302: 20uH

Connections:
/SWA: L301.1; also elsewhere on the board
/SWB: C301.2, C302.2, C303.2, J301.2, L302.2; also elsewhere on the board
/TX_LCC/LCC_N1: C301.1, C302.1, C303.1, C304.1, C305.1, L301.2
/TX_LCC/LCC_N2: C304.2, C305.2, J301.1, L302.1

Notes on the sheet:
Ideal-model estimate at 24 V full duty: V_AB1 = 21.6 Vrms, I_Lt = V_AB1/(w Lf) = 4.0 Arms, V_Ct = 50 Vrms, V_Lt = 72 Vrms.
Resonant caps, 250 V C0G 1812. Cf = C301+C302+C303 = 203 nF: about 37 V rms / 7 A rms; Ct = C304+C305 = 87.6 nF: about 50 V rms / 4 A rms at 120 W. Trim to the measured Lf and Lt.
Cf = 1/(w^2 Lf) = 203.6 nF -> C301||C302||C303 = 203.3 nF. Ct = 1/(w^2 (Lt-Lf)) = 87.3 nF -> C304||C305 = 87.6 nF.
LCC-S transmitter side, design values (see docs/design.md), f = 144 kHz: Lf 6 uH, Lt 20 uH.
J301 connects the off-board Litz TX coil; L302 is a model of that coil (not a board part).

Parts:
C401, C406: 10uF; C_1210_3225Metric; Voltage 50V
C402, C403, C405, C407, C408, C410: 100nF; C_0603_1608Metric
C404: 22uF; C_1210_3225Metric; Voltage 25V
C409: 22uF; C_1210_3225Metric; Voltage 16V
C411, C413: 1uF; C_0603_1608Metric
C412: 10nF; C_0603_1608Metric
D401, D402: SS110; D_SMA
L401: 47uH; L_Taiyo-Yuden_NR-50xx
L402: 33uH; L_Taiyo-Yuden_NR-50xx
R401, R404: 100k; R_0603_1608Metric
R402: 147k; R_0603_1608Metric
R403, R406: 10k; R_0603_1608Metric
R405: 54.9k; R_0603_1608Metric
U401, U402: LMR16006X; SOT-23-6
U403: TC2185-3.3; SOT-23-5

Connections:
+3V3: C413.1, U403.5 (VOUT); also elsewhere on the board
/TX_AuxPower/FB_5V: R405.2, R406.1, U402.3 (FB)
/TX_AuxPower/FB_12V: R402.2, R403.1, U401.3 (FB)
/TX_AuxPower/SW_5V: C408.2, D402.1 (K), L402.1, U402.6 (SW)
/TX_AuxPower/SW_12V: C403.2, D401.1 (K), L401.1, U401.6 (SW)
unnamed: C403.1, U401.1 (CB)
unnamed: R401.2, U401.4 (~SHDN)
unnamed: C408.1, U402.1 (CB)
unnamed: R404.2, U402.4 (~SHDN)
unnamed: C412.1, U403.4 (BP)

Notes on the sheet:
U403 TC2185-3.3, 150 mA max: MCU + INA240 only. Buck first, then LDO for a quieter 3.3 V rail.
VFB = 0.765 V typ (0.747-0.782 V, TI SNVSA24). Still to check: inductor saturation current, capacitor DC-bias derating.
Aux power design. U401: VOUT = 0.765 V x (1 + 147k/10k) = 12.0 V for UCC27211 VDD. U402: 0.765 V x (1 + 54.9k/10k) = 4.96 V.
LMR16006X: 60 V, 0.6 A, 700 kHz (symbol borrowed from LMR16006YQ, same pinout). L401 47 uH / L402 33 uH give about 30 % ripple at 24 V input. SS110 catch diodes (100 V, 1 A).

Parts:
C201, C204: 2.2uF; C_0805_2012Metric; Voltage 25V
C202, C205: 100nF; C_0603_1608Metric
C203, C206: 220nF; C_0805_2012Metric; Voltage 50V
U201, U202: UCC27211; HVSON-8-1EP_4x4mm_P0.8mm_EP2.2x3.1mm

Connections:
/DRV_AH: U201.3 (HO); also elsewhere on the board
/DRV_AL: U201.8 (LO); also elsewhere on the board
/DRV_BH: U202.3 (HO); also elsewhere on the board
/DRV_BL: U202.8 (LO); also elsewhere on the board
/SWA: C203.2, U201.4 (HS); also elsewhere on the board
/SWB: C206.2, U202.4 (HS); also elsewhere on the board
unnamed: C203.1, U201.2 (HB)
unnamed: C206.1, U202.2 (HB)
PWM_AH: U201.5 (HI); also elsewhere on the board
PWM_AL: U201.6 (LI); also elsewhere on the board
PWM_BH: U202.5 (HI); also elsewhere on the board
PWM_BL: U202.6 (LI); also elsewhere on the board

Notes on the sheet:
High-side gate is referenced to SWA/SWB through HS. Gate resistors R1-R4 and Rgs R6-R9 are on the root sheet.
U201/U202 UCC27211DRM (VSON-8): 120 V half-bridge driver with internal bootstrap diode. HI/LI are TTL inputs driven by STM32G474 HRTIM; dead time is set in HRTIM.
Bootstrap 220 nF (design example: 40 nC / 0.5 V -> 80 nF minimum). Above TI's typical 22-100 nF on purpose: a 100 nF X7R drops to about 80 nF under 12 V DC bias. VDD 2.2 uF + 100 nF, about 10x Cboot.

Parts:
C501, C502, C503, C504, C512: 100nF; C_0603_1608Metric
C505: 4.7uF; C_0805_2012Metric
C506, C508: 1uF; C_0603_1608Metric
C507, C509: 10nF; C_0603_1608Metric
C510, C511: 15pF; C_0603_1608Metric
D501: LED_G; LED_0603_1608Metric
FB501: 600R@100MHz; L_0603_1608Metric
J501: SWD; PinHeader_1x05_P2.54mm_Vertical
J502: UART; PinHeader_1x04_P2.54mm_Vertical
R501: 10k; R_0603_1608Metric
R502: 1k; R_0603_1608Metric
U501: STM32G474CETx; LQFP-48_7x7mm_P0.5mm
Y501: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3V3: C501.1, C502.1, C503.1, C504.1, C505.1, FB501.1, J501.1, J502.1, R502.1, U501.1 (VBAT), U501.24 (VDD), U501.36 (VDD), U501.48 (VDD); also elsewhere on the board
/TX_MCU/+3V3A: C506.1, C507.1, C508.1, C509.1, FB501.2, U501.20 (VREF+), U501.21 (VDDA)
/TX_MCU/LED_STAT: D501.1 (K), U501.2 (PC13)
/TX_MCU/NRST: C512.2, J501.5, U501.7 (PG10)
/TX_MCU/SWCLK: J501.2, U501.38 (PA14)
/TX_MCU/SWDIO: J501.4, U501.37 (PA13)
/TX_MCU/UART_RX: J502.3, U501.44 (PB7)
/TX_MCU/UART_TX: J502.2, U501.43 (PB6)
ISNS_TX: U501.9 (PA1); also elsewhere on the board
unnamed: D501.2 (A), R502.2
unnamed: R501.1, U501.45 (PB8)
unnamed: C510.1, U501.5 (PF0), Y501.1
unnamed: C511.1, U501.6 (PF1), Y501.3
PWM_AH: U501.30 (PA8); also elsewhere on the board
PWM_AL: U501.31 (PA9); also elsewhere on the board
PWM_BH: U501.32 (PA10); also elsewhere on the board
PWM_BL: U501.33 (PA11); also elsewhere on the board
VBUS_SNS: U501.8 (PA0); also elsewhere on the board

Notes on the sheet:
J502 UART is reserved for the RX-to-TX feedback link (ASK or radio, not decided).
PA1 ISNS_TX -> ADC and COMP1_INP; COMP1 output drives an HRTIM fault for fast over-current shutdown. PA0 VBUS_SNS -> ADC.
PG10 = NRST, PB8 = BOOT0 (10k pull-down). HSE 8 MHz, load caps 15 pF assume CL = 10 pF: check the crystal datasheet.
STM32G474CETx. HRTIM1 CHA1/CHA2 = PWM_AH/PWM_AL, CHB1/CHB2 = PWM_BH/PWM_BL: phase shift between legs A and B, dead time set in HRTIM.

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
Board: 4 copper layers, 82.0 x 60.0 mm, 92 parts (0 on the bottom side), 50 nets.

File p1_tx/fab/p1_tx-bom.csv:

"Refs","Value","Voltage","Footprint","Qty","DNP"
"C1","220uF","50V","Capacitor_SMD:CP_Elec_10x10.5","1",""
"C2,C3","4.7uF","50V","Capacitor_SMD:C_1210_3225Metric","2",""
"C101,C401,C406","10uF","50V","Capacitor_SMD:C_1210_3225Metric","3",""
"C102,C105,C202,C205,C402,C403,C405,C407,C408,C410,C501,C502,C503,C504,C512","100nF","","Capacitor_SMD:C_0603_1608Metric","15",""
"C104","1nF","","Capacitor_SMD:C_0603_1608Metric","1",""
"C201,C204","2.2uF","25V","Capacitor_SMD:C_0805_2012Metric","2",""
"C203,C206","220nF","50V","Capacitor_SMD:C_0805_2012Metric","2",""
"C301,C302","100nF","250V C0G","Capacitor_SMD:C_1812_4532Metric","2",""
"C303","3.3nF","250V C0G","Capacitor_SMD:C_1812_4532Metric","1",""
"C304","82nF","250V C0G","Capacitor_SMD:C_1812_4532Metric","1",""
"C305","5.6nF","250V C0G","Capacitor_SMD:C_1812_4532Metric","1",""
"C404","22uF","25V","Capacitor_SMD:C_1210_3225Metric","1",""
"C409","22uF","16V","Capacitor_SMD:C_1210_3225Metric","1",""
"C411,C413,C506,C508","1uF","","Capacitor_SMD:C_0603_1608Metric","4",""
"C412,C507,C509","10nF","","Capacitor_SMD:C_0603_1608Metric","3",""
"C505","4.7uF","","Capacitor_SMD:C_0805_2012Metric","1",""
"C510,C511","15pF","","Capacitor_SMD:C_0603_1608Metric","2",""
"D101","SMAJ28A","","Diode_SMD:D_SMA","1",""
"D401,D402","SS110","","Diode_SMD:D_SMA","2",""
"D501","LED_G","","LED_SMD:LED_0603_1608Metric","1",""
"F101","10A","","Fuse:Fuse_Littelfuse-NANO2-451_453","1",""
"FB501","600R@100MHz","","Inductor_SMD:L_0603_1608Metric","1",""
"J101","XT30_24V_IN","","Connector_AMASS:AMASS_XT30PW-M_1x02_P2.50mm_Horizontal","1",""
"J301","TX_COIL","","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizontal","1",""
"J501","SWD","","Connector_PinHeader_2.54mm:PinHeader_1x05_P2.54mm_Vertical","1",""
"J502","UART","","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical","1",""
"L301","6uH","","Inductor_SMD:L_12x12mm_H8mm","1",""
"L302","20uH","","","1",""
"L401","47uH","","Inductor_SMD:L_Taiyo-Yuden_NR-50xx","1",""
"L402","33uH","","Inductor_SMD:L_Taiyo-Yuden_NR-50xx","1",""
"Q1,Q2,Q3,Q4","BSC070N10NS3G","","Package_SON:Infineon_PG-TDSON-8_6.15x5.15mm","4",""
"R1,R2,R3,R4","10R","","Resistor_SMD:R_0603_1608Metric","4",""
"R6,R7,R8,R9,R104,R403,R406,R501","10k","","Resistor_SMD:R_0603_1608Metric","8",""
"R101","2m","","Resistor_SMD:R_Shunt_Vishay_WSK2512_6332Metric_T1.19mm","1",""
"R102","100","","Resistor_SMD:R_0603_1608Metric","1",""
"R103","150k","","Resistor_SMD:R_0603_1608Metric","1",""
"R401,R404","100k","","Resistor_SMD:R_0603_1608Metric","2",""
"R402","147k","","Resistor_SMD:R_0603_1608Metric","1",""
"R405","54.9k","","Resistor_SMD:R_0603_1608Metric","1",""
"R502","1k","","Resistor_SMD:R_0603_1608Metric","1",""
"U101","INA240A2D","","Package_SO:SOIC-8_3.9x4.9mm_P1.27mm","1",""
"U201,U202","UCC27211","","Package_SON:HVSON-8-1EP_4x4mm_P0.8mm_EP2.2x3.1mm","2",""
"U401,U402","LMR16006X","","Package_TO_SOT_SMD:SOT-23-6","2",""
"U403","TC2185-3.3","","Package_TO_SOT_SMD:SOT-23-5","1",""
"U501","STM32G474CETx","","Package_QFP:LQFP-48_7x7mm_P0.5mm","1",""
"Y501","8MHz","","Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm","1",""
